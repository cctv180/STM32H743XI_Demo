# Keil uVision project project.uvprojx, settings and files
target project (6230000::V6.23::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: project +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: fromelf.exe --text -a -c --output="!L_dis.asm" "!L"
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY,SHELL_CFG_USER=\"shell_cfg_user.h\"
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User;../User/bsp;../User/bsp/inc;../OpenLib/utils_lib;../OpenLib/xxtea/Lib;../OpenLib/xxtea/Lib/example;../OpenLib/KFIFO;../OpenLib/MultiButton;../OpenLib/MultiTimer;../OpenLib/MultiTimer/Lib;../OpenLib/perf_counter;../OpenLib/letter_shell;../OpenLib/letter_shell/Lib/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\sct_example.sct
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_fmc_io.c bsp_fmc_sdram.c bsp_led.c bsp_key.c bsp_dma.c bsp_uart.c bsp_tim_pwm.c bsp_beep.c bsp_qspi.c bsp_tft_h7.c bsp_sdio_sd.c
  group UserApp
    ../User/: main.c
    ../OpenLib/utils_lib/: utils_lib.c
  group OpenLib/xxtea
    ../OpenLib/xxtea/: base64_cmd.c xxtea_cmd.c
    ../OpenLib/xxtea/Lib/example/: base64.c
    ../OpenLib/xxtea/Lib/: xxtea.c
  group OpenLib/KFIFO
    ../OpenLib/KFIFO/: ring_buffer.c
  group OpenLib/MultiButton
    ../OpenLib/MultiButton/: multi_button.c
  group OpenLib/MultiTimer
    ../OpenLib/MultiTimer/: timer_port.c
    ../OpenLib/MultiTimer/Lib/: MultiTimer.c
  group OpenLib/perf_counter
    ../OpenLib/perf_counter/: perf_counter.c perf_counter.h systick_wrapper_ual.s perfc_port_default.c
  group OpenLib/letter_shell
    ../OpenLib/letter_shell/: shell_cfg_user.h shell_port.c
    ../OpenLib/letter_shell/Lib/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
software components: CMSIS:CORE 5.6.0
